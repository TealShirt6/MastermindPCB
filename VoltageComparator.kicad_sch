File: VoltageComparator.kicad_sch (KiCad schematic)
At the start: 6 parts, among them U18 LM324, U19 74LS08

Commit message: Finished?
Parts:
- R10: value 2.2k -> 10k
